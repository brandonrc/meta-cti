## conf/distro/include/cti-hadron-orin-nano.conf.conf
```bitbake
DEPLOY_CONF_NAME = "NVIDIA CTI Hadron Orin Nano"

include conf/distro/include/jetson.inc
```
